options:
  parameters:
    generate_options: qt_gui
    id: test0_usrp
    output_language: python
    title: USRP loopback
  states: {}

blocks:
- name: fc
  id: variable
  parameters:
    value: 100e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.05'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '0.05'
    freq: 100e3
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_multiply_conjugate_cc_1
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: IQ constellation
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: Phase (arg(I + jQ))
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Phase
    yunit: rad
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    dev_addr: addr=192.168.10.2
    gain0: '5'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    dev_addr: addr=192.168.10.2
    gain0: '15'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_conjugate_cc_1, '1']
- [blocks_complex_to_arg_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', blocks_complex_to_arg_0, '0']
- [blocks_multiply_conjugate_cc_1, '0', qtgui_const_sink_x_0, '0']
- [uhd_usrp_source_0, '0', blocks_multiply_conjugate_cc_1, '0']

metadata:
  file_format: 1
  grc_version: 3.9.8.0
